# Keil uVision project Project.uvprojx, settings and files
target STM32L053C8_DISC_USB (ARM-ADS)
  device: STM32L053C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L053C8_DISC_USB
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx,USE_STM32L0538_DISCO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L0538-Discovery;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;../../../../../../Middlewares/ST/STM32_TouchSensing_Library/inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32L0xx_DISC
    ../../../../../../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
  group Application/User
    ../Src/: stm32l0xx_it.c stm32l0xx_hal_msp.c usbd_desc.c main.c tsl_user.c usbd_conf.c
  group Middlewares/STM32_TouchSensing_Library
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl.c tsl_dxs.c tsl_object.c tsl_filter.c tsl_ecs.c tsl_linrot.c tsl_globals.c tsl_time.c tsl_acq_tsc.c tsl_touchkey.c tsl_acq.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_dma.c stm32l0xx_hal_tsc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_rcc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_spi.c stm32l0xx_hal_pcd.c
software components: CMSIS:CORE 4.3.0
