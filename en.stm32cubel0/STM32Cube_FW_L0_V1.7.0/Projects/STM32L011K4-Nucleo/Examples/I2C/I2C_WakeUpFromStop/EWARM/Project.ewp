# IAR project Project.ewp, settings and files
configuration STM32L011K4_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L011K4 ST STM32L011K4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L011xx; USE_STM32L0XX_NUCLEO_32; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo_32; ..\..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L011K4-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32L011xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Example/EWARM
    ./: startup_stm32l011xx.s
  group Drivers/BSP/STM32L0xx_Nucleo_32
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo_32/: stm32l0xx_nucleo_32.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
